FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

OBMC_CONSOLE_HOST_TTY = "ttyS0"

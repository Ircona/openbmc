RDEPENDS_${PN}-inventory += " phosphor-cooling-type ircona-fpga"
RDEPENDS_${PN}-extras += " phosphor-webui"
